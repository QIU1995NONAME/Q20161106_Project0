# Keil uVision project QProject0000.uvproj, settings and files
target STM32F103ZET6 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103ZET6 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\include;..\src\Fatfs\include;..\src\HAL\include;..\src\Application\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Main
    ../src/Main/: main.cpp
  group Fatfs
    ../src/Fatfs/: diskio.cpp ff.cpp
  group Interrupts
    ../src/Interrupts/: it_exti.cpp it_timer.cpp it_usart.cpp stm32f10x_it.c
  group HAL
    ../src/HAL/: beep.cpp e6a2.cpp exti.cpp flash.cpp fsmc.cpp gpio.cpp key.cpp led.cpp nvic.cpp sd.cpp spi.cpp systick.cpp tft.cpp timer.cpp touch.cpp usart.cpp
  group Application
    ../src/Application/: fan.cpp fatfs.cpp gui.cpp memory.cpp q_misc.cpp q_signal.cpp tim6heartbeat.cpp __frame__.cpp __frame_task__.cpp
